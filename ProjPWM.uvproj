# Keil uVision project ProjPWM.uvproj, settings and files
target MKD51 (MCS-51)
  device: 8031AH Intel
  cpu: IRAM(0-0x7F) CLOCK(12000000)
  output: CiASM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Program
    ./: main.c proc51.asm
target Programator (MCS-51)
  device: 8031AH Intel
  cpu: IRAM(0-0x7F) CLOCK(12000000)
  output: CiASM +hex
  c flags: Optimize=8 SizeSpeed=1
